## konfig_templates/Kconfig.STM32F03C8
```kconfig
orsource "components/**/Kconfig.projbuild"
orsource ".pio/libdeps/STM32F03C8/**/Kconfig.projbuild"
```
